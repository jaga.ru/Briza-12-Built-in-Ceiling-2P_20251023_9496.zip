Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-01-07T11:50:16
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20181011_1500(x64) - Exporter 18.4.0.0 - ARCHICAD Connection 21.0.0.6007

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (3)
Description: Flow
Pset_DistributionPortPipe - ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 20 mm; ConnectorDiameter: 20 mm; NominalWidth: 20 mm; NominalHeight: 20 mm
Name | FlowDirection | PortNumber
Port_307158 | SOURCE | 1
Port_307158 | SOURCE | 2
Port_307158 | SINK | 3

# IfcEnergyConversionDevice: bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5, RSen_55_ME_FB_fan coils - 2 pipes_jaga:bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5:307158
In: Level 1
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: RSen_x_rgb 161 161 160 T00 sanblast gray 001_gen
Type - Constraints - Default Elevation: 0 mm
Type - Construction - RSen_C_diameter_type: OD; RSen_C_diameter_type_index: 1; TBQen_C_SOg_01: standard; TBQen_C_SOg_02: none_gen
Type - Dimensions - RSen_C_depth: 127.5 mm; RSen_C_height: 381 mm; RSen_C_length: 505 mm
Type - Electrical - RSen_E_c01_apparent_power: 0 W; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: yes; RSen_E_c01_load_class: Other; RSen_E_c01_number_of_poles: 1; RSen_E_c01_power: 0 W; RSen_E_c01_power_factor: 1; RSen_E_c01_voltage: 24 V
Type - Identity Data - Description: jaga_briza_concealed ceiling mounted; Manufacturer: Jaga; Model: Briza; RSen_C_code_article: BZBC.038052/20; RSen_C_code_ETIM: Air-conditioning split system – inside unit (evaporator); RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC011580&classVersion=4; RSen_C_code_product: FWM03DAF; RSen_C_code_product_class: FWM-DAF; RSen_C_content_creator: © ThorbiQ; RSen_C_content_date_changed: 31/07/2018; RSen_C_content_date_issue: 31/07/2018; RSen_C_content_provider: Jaga; RSen_C_content_version: 1.1.0; RSen_C_description: jaga_briza_concealed ceiling mounted; RSen_C_IFC_version: 2x3; RSen_C_license: Creative Commons Attribution NoDerivs (CC-ND); RSen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSen_C_model: Briza; RSen_C_revit_version: 2016; RSen_C_type: 2-pipe; RSen_C_type_comments: Concealed ceiling mounted; TBQ_I BaseKeynote: 55.10.10.10; Type Name: bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5; URL: www.jaga.be
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 161 161 160 T00 sanblast gray 001_gen; TBQ_I Colour: -; TBQ_I Colour chart: -
Type - Mechanical - RSen_P_c01_volume_flow: 0 m3/s; RSen_P_c02_volume_flow: 0 m3/s; RSen_P_c05_load_value: 0; TBQ_I Air flow rate_high: 0 m3/s; TBQ_I Air flow rate_low: 0 m3/s; TBQ_I Air flow rate_nom: 0 m3/s
Type - Model Properties - TBQ_I Depth_cm: 11,7; TBQ_I Height_cm: 38; TBQ_I Length_cm: 52
Type - Other - Category: Mechanical Equipment; Family Name: RSen_55_ME_FB_fan coils - 2 pipes_jaga; RSen_E_c01_description: c01_el; RSen_E_c01_power_factor_state: Lagging; RSen_E_c01_system_type: Power - Balanced; RSen_E_c01_yes_no: yes; RSen_E_c02_description: c02_controls; RSen_E_c02_yes_no: yes; RSen_P_c01_description: c01_supply hydraulic connection; RSen_P_c01_diameter: 20 mm; RSen_P_c01_diameter_calc: 20 mm; RSen_P_c01_flow_configuration: Preset; RSen_P_c01_flow_direction: In; RSen_P_c01_loss_method: Not Defined; RSen_P_c01_system_classification: Hydronic Supply; RSen_P_c01_yes_no: yes; RSen_P_c02_description: c02_return hydraulic connection; RSen_P_c02_diameter: 20 mm; RSen_P_c02_diameter_calc: 20 mm; RSen_P_c02_flow_configuration: Preset; RSen_P_c02_flow_direction: Out; RSen_P_c02_loss_method: Not Defined; RSen_P_c02_system_classification: Hydronic Return; RSen_P_c02_yes_no: yes; RSen_P_c05_description: c05_drain piping connection; RSen_P_c05_diameter: 20 mm; RSen_P_c05_diameter_calc: 20 mm; RSen_P_c05_flow_configuration: Fixture Units; RSen_P_c05_flow_direction: Out; RSen_P_c05_loss_method: Not Defined; RSen_P_c05_system_classification: Sanitary; RSen_P_c05_yes_no: yes
Pset_DistributionFlowElementCommon - Reference: RSen_55_ME_FB_fan coils - 2 pipes_jaga:bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Pset_ProductRequirements - Category: Mechanical Equipment
Constraints - Elevation: 0 mm; Host: Reference Plane : h_rightleft
Construction - RSen_C_accessory_ME_01: none_gen; RSen_C_alignment: Center; RSen_C_alignment_index: 0; RSen_C_connection_set_CHr: none; RSen_C_connection_set_CHs: none; RSen_C_suspension_height: 0 mm; TBQen_C_GOg: no; TBQen_C_SOg: yes
Dimensions - Area: 7.27161 m2; Volume: 0.630772 m3
Graphics - RSen_C_clearance_zone: no; RSen_C_connection_zone: no; RSen_C_maintenance_zone: no; RSen_C_neighbour_unit: no; RSen_C_neighbour_unit_displacement_back: 0 mm; RSen_C_neighbour_unit_displacement_front: 0 mm; RSen_C_neighbour_unit_displacement_left: 0 mm; RSen_C_neighbour_unit_displacement_right: 0 mm; TBQen_C_logo: yes
Identity Data - Mark: 12
Mechanical - System Classification: Power,Controls,Sanitary,Hydronic Supply,Hydronic Return
Mechanical - Flow - RSen_M_air_flow_rate: Low; RSen_M_air_flow_rate_index: 0; RSen_M_flow_rate: 0 m3/s
Other - Family: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5; Family and Type: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5; Type: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5; Type Id: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzbc.038052/20 - concealed ceiling mounted - 2-pipe_jaga_briza_lxhxd 505x381x127,5
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/en/daikin
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
